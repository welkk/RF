<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Demo_stm8v01.ewp</path>
  </project>
  <batchBuild/>
</workspace>


